Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: Tekla.ifc
Time: 2019-06-21T15:27:24
Author: PORTCM01\professeur
Organization: Structural Designer
Written by: IFC Database version:Work
Made in: Tekla Structures Educational 2017 Service Pack 2, IFC Export Version: 4.0.0.0 May 16 2017

# IfcSite, Undefined
RefElevation: 0 mm

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C100*50*3 (6)
In: Undefined
Description: C100*50*3; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: A6; Repère d'assemblage: A6; Finition: GALVA; Phase: 1; Classe: 2; Matériau: S235JR; Profil: C100*50*3; Nom: PANNES
Tekla Quantités - Poids: 11 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 86.4 m2; Surface nette: 1 m2; Hauteur: 100 mm; Largeur: 50 mm; Longueur: 2475.3 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A6
BaseQuantities - Length: 2475.3 mm; OuterSurfaceArea: 0.953869 m2; NetVolume: 0.00140678 m3; NetWeight: 11.0432 kg
Name | Niveau bas | Niveau haut
2 x PANNES | +1.909 | +2.016
2 x PANNES | +2.151 | +2.258
2 x PANNES | +2.393 | +2.500

# IfcBeam: IPE140 (3)
In: Undefined
Description: IPE140; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +1.864; Finition: GALVA; Matériau: S235JR; Profil: IPE140; Nom: ARBA
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 42.8 m2; Surface nette: 1.6 m2; Hauteur: 140 mm; Largeur: 73 mm
Pset_BeamCommon - LoadBearing: yes
Name | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Phase | Classe | Poids (kg) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
ARBA | +2.508 | 5(?) | 1(?) | 2 | 4 | 37.4 | 2906.2 | 2906.2 | 1.60132 | 0.00460998 | 36.1884
ARBA | +2.513 | 3(?) | 2(?) | 4 | 3 | 37.8 | 2938.2 | 2938.19 | 1.61894 | 0.00466118 | 36.5903
ARBA | +2.508 | 5(?) | 12(?) | 3 | 4 | 37.4 | 2906.2 | 2906.2 | 1.60132 | 0.00460998 | 36.1884

# IfcBeam: L40*4 (4)
In: Undefined
Description: L40*4; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: A7; Repère d'assemblage: A7; Finition: GALVA; Phase: 5; Classe: 3; Matériau: S235JR; Profil: L40*4; Nom: CVT
Tekla Quantités - Poids: 6.5 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.1 m2; Surface nette: 0.4 m2; Hauteur: 40 mm; Largeur: 40 mm; Longueur: 2709 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A7
BaseQuantities - Length: 2709.05 mm; OuterSurfaceArea: 0.419903 m2; NetVolume: 0.000823551 m3; NetWeight: 6.46487 kg
Name | Niveau bas | Niveau haut
CVT | +2.085 | +2.354
CVT | +2.129 | +2.403
CVT | +1.843 | +2.112
CVT | +1.887 | +2.162

# IfcBeam: TC-C50*50*3.2, TREILLIS
In: Undefined
Description: TC-C50*50*3.2; Material: STEEL/S235JR
Tekla Quantités - Poids: 22.2 kg; Volume: 0 m3; Surface supérieure totale: 0.2 m2; Surface par tonne: 41.6 m2; Surface nette: 1 m2; Hauteur: 50 mm; Largeur: 50 mm; Longueur: 4820 mm
Tekla Commun - Niveau bas: +2.450; Niveau haut: +2.500; Repère de pièce: 35(?); Repère d'assemblage: 7(?); Finition: GALVA; Phase: 1; Classe: 13; Matériau: S235JR; Profil: TC-C50*50*3.2; Nom: TREILLIS
Pset_BeamCommon - LoadBearing: yes; Reference: 35(?)
BaseQuantities - Length: 4820.03 mm; OuterSurfaceArea: 0.925445 m2; NetVolume: 0.00288739 m3; NetWeight: 22.666 kg

# IfcBeam: TUBE-C-50*50*2.5 (2)
In: Undefined
Description: TUBE-C-50*50*2.5; Material: STEEL/S235JR
Tekla Commun - Finition: GALVA; Phase: 6; Classe: 3; Matériau: S235JR; Profil: TUBE-C-50*50*2.5
Tekla Quantités - Poids: 8.3 kg; Volume: 0 m3; Surface supérieure totale: 0.1 m2; Surface par tonne: 52.6 m2; Surface nette: 0.4 m2; Hauteur: 50 mm; Largeur: 50 mm; Longueur: 2232 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - Length: 2232 mm; OuterSurfaceArea: 0.43524 m2; NetVolume: 0.0010602 m3; NetWeight: 8.32257 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Nom
BUTON | +1.905 | +1.955 | 26(?) | A2(?) | BUTON
BUTON CVT | +1.880 | +1.930 | 25(?) | A1(?) | BUTON CVT

# IfcBeam: TUBE-R-70*40*3 (4)
In: Undefined
Description: TUBE-R-70*40*3; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: A3; Repère d'assemblage: A3; Finition: GALVA; Phase: 1; Classe: 6; Matériau: S235JR; Profil: TUBE-R-70*40*3; Nom: LISSES
Tekla Quantités - Poids: 12 kg; Volume: 0 m3; Surface supérieure totale: 0.2 m2; Surface par tonne: 42.9 m2; Surface nette: 0.4 m2; Hauteur: 70 mm; Largeur: 40 mm; Longueur: 2474 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A3
BaseQuantities - Length: 2474 mm; OuterSurfaceArea: 0.517066 m2; NetVolume: 0.00151882 m3; NetWeight: 11.9227 kg
Name | Niveau bas | Niveau haut
2 x LISSES | +1.380 | +1.420
2 x LISSES | +0.280 | +0.320

# IfcBeam: TUBE-R-80*40*3 (4)
In: Undefined
Description: TUBE-R-80*40*3; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: A4; Repère d'assemblage: A4; Finition: GALVA; Phase: 1; Classe: 13; Matériau: S235JR; Profil: TUBE-R-80*40*3; Nom: LISSES
Tekla Quantités - Poids: 12.6 kg; Volume: 0 m3; Surface supérieure totale: 0.2 m2; Surface par tonne: 52.9 m2; Surface nette: 0.7 m2; Hauteur: 80 mm; Largeur: 40 mm; Longueur: 2837.5 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A4
BaseQuantities - Length: 2837.5 mm; OuterSurfaceArea: 0.663975 m2; NetVolume: 0.00191349 m3; NetWeight: 15.0209 kg
Name | Niveau bas | Niveau haut
2 x LISSES | +1.380 | +1.420
2 x LISSES | +0.280 | +0.320

# IfcColumn: HEA140 (2)
In: Undefined
Description: HEA140; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +0.040; Niveau haut: +2.533; Repère de pièce: 2(?); Finition: GALVA; Classe: 4; Matériau: S235JR; Profil: HEA140; Nom: POTEAU AV
Tekla Quantités - Poids: 61.5 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 32.2 m2; Surface nette: 2 m2; Hauteur: 133 mm; Largeur: 140 mm; Longueur: 2493.2 mm
Pset_ColumnCommon - LoadBearing: yes; Reference: 2(?)
BaseQuantities - Length: 2493.15 mm; OuterSurfaceArea: 1.97956 m2; NetVolume: 0.00748887 m3; NetWeight: 58.7877 kg
Name | Repère d'assemblage | Phase
POTEAU AV | 9(?) | 2
POTEAU AV | 8(?) | 3

# IfcColumn: HEA160 (3)
In: Undefined
Description: HEA160; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +0.040; Niveau haut: +1.995; Repère de pièce: 8(?); Finition: GALVA; Matériau: S235JR; Profil: HEA160; Nom: Poteau AR
Tekla Quantités - Poids: 59.5 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 29.8 m2; Surface nette: 1.8 m2; Hauteur: 152 mm; Largeur: 160 mm; Longueur: 1954.5 mm
Pset_ColumnCommon - LoadBearing: yes; Reference: 8(?)
BaseQuantities - Length: 1954.53 mm; OuterSurfaceArea: 1.77081 m2; NetVolume: 0.00715102 m3; NetWeight: 56.1355 kg
Name | Repère d'assemblage | Phase | Classe
Poteau AR | 5(?) | 2 | 4
Poteau AR | 4(?) | 4 | 3
Poteau AR | 6(?) | 3 | 4

# IfcDiscreteAccessory: ABOUT POUTRE (6)
In: Undefined
Material: STEEL/S235JR
Tekla Commun - Finition: GALVA; Matériau: S235JR; Nom: ABOUT POUTRE
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Largeur: 10 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.0001 m2
Name | Description = Profil | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Phase | Classe | Poids (kg) | Surface par tonne (m2) | Surface nette (m2) | Hauteur (mm) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
ABOUT POUTRE | PL10*140 | +2.322 | +2.562 | 22(?) | 2(?) | 4 | 3 | 2.6 | 29 | 0.1 | 140 | 240 | 0.0754549 | 0.0336 | 0.000331927 | 0.000336
ABOUT POUTRE | PL10*140 | +2.322 | +2.562 | 22 | 7(?) | 1 | 13 | 2.6 | 28.5 | 0.1 | 140 | 240 | 0.0748 | 0.0336 | 0.000336 | 0.000336
2 x ABOUT POUTRE | PL10*125 | +1.900 | +2.050 | 21(?) | 7(?) | 1 | 13 | 1.4 | 30.3 | 0 | 124.5 | 150 | 0.0434949 | 0.018675 | 0.000182677 | 0.00018675
2 x ABOUT POUTRE | PL10*122 | +2.400 | +2.522 | 19(?) | 7(?) | 1 | 13 | 1.1 | 31.4 | 0 | 122 | 124.5 | 0.0330234 | 0.0151891 | 0.000134123 | 0.000138196

# IfcDiscreteAccessory: JARRET (5)
In: Undefined
Description: IPE140; Material: STEEL/S235JR
Tekla Commun - Finition: GALVA; Classe: 1; Matériau: S235JR; Profil: IPE140; Nom: JARRET
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 42.8 m2; Surface nette: 0.1 m2; Largeur: 73 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00164 m2
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Phase | Poids (kg) | Hauteur (mm) | Longueur (mm) | NetArea (m2) = GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
JARRET | +1.716 | +1.917 | 6(?) | 1(?) | 2 | 4.6 | 116.7 | 361.1 | 0.198966 | 0.000277328 | 0.000592204
JARRET | +2.240 | +2.362 | 4(?) | 1(?) | 2 | 4 | 115.4 | 308.7 | 0.170096 | 0.000237732 | 0.000506276
JARRET | +1.716 | +1.917 | 6(?) | 2(?) | 4 | 4.6 | 116.7 | 361.1 | 0.198966 | 0.000277328 | 0.000592204
JARRET | +1.716 | +1.917 | 6(?) | 12(?) | 3 | 4.6 | 116.7 | 361.1 | 0.198966 | 0.000277328 | 0.000592204
JARRET | +2.240 | +2.362 | 4(?) | 12(?) | 3 | 4 | 115.4 | 308.7 | 0.170096 | 0.000237732 | 0.000506276

# IfcDiscreteAccessory: PLAT (26)
In: Undefined
Material: STEEL/S235JR
Tekla Commun - Finition: GALVA; Matériau: S235JR; Nom: PLAT
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description = Profil | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Phase | Classe | Poids (kg) | Surface par tonne (m2) | Surface nette (m2) | Hauteur (mm) | Largeur (mm) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
PLAT | PL10*59 | +0.270 | +0.280 | 46 | 6(?) | 3 | 99 | 0.6 | 31.6 | 0 | 59 | 10 | 131 | 0.0189408 | 0.007729 | 0.0001 | 0.00007629 | 0.00007629
PLAT | PL10*59 | +1.370 | +1.380 | 46 | 6(?) | 3 | 99 | 0.6 | 31.6 | 0 | 59.1 | 10 | 131 | 0.018955 | 0.00774111 | 0.0001 | 0.000076356 | 0.000076356
PLAT | PL10*59 | +1.370 | +1.380 | 46 | 4(?) | 4 | 99 | 0.6 | 31.6 | 0 | 59 | 10 | 131 | 0.0189408 | 0.007729 | 0.0001 | 0.00007629 | 0.00007629
2 x PLAT | PL10*59 | +0.270 | +0.280 | 46 | 4(?) | 4 | 99 | 0.6 | 31.6 | 0 | 59 | 10 | 131 | 0.0189408 | 0.007729 | 0.0001 | 0.00007629 | 0.00007629
PLAT | PL10*59 | +1.370 | +1.380 | 14 | 4(?) | 4 | 99 | 0.6 | 31.6 | 0 | 59 | 10 | 131 | 0.0189408 | 0.007729 | 0.0001 | 0.00007629 | 0.00007629
PLAT | PL10*59 | +1.370 | +1.380 | 13 | 5(?) | 2 | 99 | 0.6 | 31.7 | 0 | 59 | 10 | 131 | 0.0187988 | 0.00771808 | 0.0001 | 0.0000756301 | 0.0000756301
PLAT | PL6*59 | +0.274 | +0.280 | 41 | 5(?) | 2 | 99 | 0.3 | 48.6 | 0 | 59 | 6 | 131 | 0.0174677 | 0.007729 | 0.000036 | 0.000045774 | 0.000045774
2 x PLAT | PL10*70 | +1.710 | +1.720 | 12 | 5(?) | 2 | 1 | 0.6 | 31 | 0 | 70 | 10 | 134 | 0.0222143 | 0.00938 | 0.0001 | 0.00009155 | 0.00009155
PLAT | PL10*122 | +1.706 | +2.003 | 10(?) | 1(?) | 2 | 1 | 2.8 | 28.5 | 0.1 | 122 | 10 | 297.3 | 0.0809151 | 0.0809151 | 0.00122 | 0.00036265 | 0.00036265
PLAT | PL10*150 | +1.969 | +2.004 | 7(?) | 5(?) | 2 | 1 | 1.7 | 29.9 | 0 | 150 | 10 | 144.4 | 0.0498486 | 0.0491936 | 0.0015 | 0.00021246 | 0.000216533
2 x PLAT | PL10*60 | +2.237 | +2.247 | 11 | 9(?) | 2 | 1 | 0.5 | 31.7 | 0 | 60 | 10 | 116 | 0.0170114 | 0.00696 | 0.0001 | 0.00006816 | 0.00006816
PLAT | PL10*122 | +2.230 | +2.505 | 9(?) | 1(?) | 2 | 1 | 2.6 | 28.5 | 0.1 | 122 | 10 | 275.3 | 0.0751198 | 0.0751198 | 0.00122 | 0.000335869 | 0.000335869
2 x PLAT | PL10*70 | +1.710 | +1.720 | 12 | 4(?) | 4 | 1 | 0.6 | 31 | 0 | 70 | 10 | 134 | 0.0222143 | 0.00938 | 0.0001 | 0.00009155 | 0.00009155
PLAT | PL10*122 | +1.706 | +2.003 | 10(?) | 2(?) | 4 | 1 | 2.8 | 28.5 | 0.1 | 122 | 10 | 297.3 | 0.0809151 | 0.0809151 | 0.00122 | 0.00036265 | 0.00036265
PLAT | PL10*150 | +1.969 | +2.004 | 7(?) | 4(?) | 4 | 1 | 1.7 | 29.9 | 0 | 150 | 10 | 144.4 | 0.0498486 | 0.0491936 | 0.0015 | 0.00021246 | 0.000216533
2 x PLAT | PL10*70 | +1.710 | +1.720 | 12 | 6(?) | 3 | 1 | 0.6 | 31 | 0 | 70 | 10 | 134 | 0.0222143 | 0.00938 | 0.0001 | 0.00009155 | 0.00009155
PLAT | PL10*122 | +1.706 | +2.003 | 10(?) | 12(?) | 3 | 1 | 2.8 | 28.5 | 0.1 | 122 | 10 | 297.3 | 0.0809151 | 0.0809151 | 0.00122 | 0.00036265 | 0.00036265
PLAT | PL10*150 | +1.969 | +2.004 | 7(?) | 6(?) | 3 | 1 | 1.7 | 29.9 | 0 | 150 | 10 | 144.4 | 0.0498486 | 0.0491936 | 0.0015 | 0.00021246 | 0.000216533
2 x PLAT | PL10*60 | +2.237 | +2.247 | 11 | 8(?) | 3 | 1 | 0.5 | 31.7 | 0 | 60 | 10 | 116 | 0.0170114 | 0.00696 | 0.0001 | 0.00006816 | 0.00006816
PLAT | PL10*122 | +2.230 | +2.505 | 9(?) | 12(?) | 3 | 1 | 2.6 | 28.5 | 0.1 | 122 | 10 | 275.3 | 0.0751198 | 0.0751198 | 0.00122 | 0.000335869 | 0.000335869

# IfcDiscreteAccessory: PLATINE (12)
In: Undefined
Description: PL6*60; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: 30(?); Finition: GALVA; Classe: 99; Matériau: S235JR; Profil: PL6*60; Nom: PLATINE
Tekla Quantités - Poids: 0.3 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 49.3 m2; Surface nette: 0 m2; Hauteur: 60 mm; Largeur: 6 mm; Longueur: 100 mm
Pset_PlateCommon - LoadBearing: yes; Reference: 30(?)
BaseQuantities - NetArea: 0.01392 m2; GrossArea: 0.006 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.000036 m3; GrossVolume: 0.000036 m3
Name | Niveau bas | Niveau haut | Repère d'assemblage | Phase
PLATINE | +1.902 | +2.002 | 1(?) | 2
2 x PLATINE | +1.902 | +2.002 | 2(?) | 4
PLATINE | +1.902 | +2.002 | 12(?) | 3
PLATINE | +2.144 | +2.244 | 1(?) | 2
2 x PLATINE | +2.144 | +2.244 | 2(?) | 4
PLATINE | +2.144 | +2.244 | 12(?) | 3
PLATINE | +2.386 | +2.486 | 12(?) | 3
PLATINE | +2.386 | +2.486 | 1(?) | 2
2 x PLATINE | +2.386 | +2.486 | 2(?) | 4

# IfcDiscreteAccessory: PLAT_PLIEE (8)
In: Undefined
Description: L80*80*8; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: 29; Finition: GALVA; Classe: 99; Matériau: S235JR; Profil: L80*80*8; Nom: PLAT_PLIEE
Tekla Quantités - Poids: 0.8 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 36.7 m2; Surface nette: 0 m2; Hauteur: 80 mm; Largeur: 80 mm; Longueur: 80 mm
Pset_PlateCommon - LoadBearing: yes; Reference: 29
BaseQuantities - NetArea: 0.028032 m2; GrossArea: 0.028032 m2; CrossSectionArea: 0.00124979 m2; NetVolume: 0.00009728 m3; GrossVolume: 0.00009728 m3
Name | Niveau bas | Niveau haut | Repère d'assemblage | Phase
PLAT_PLIEE | +1.300 | +1.380 | 9(?) | 2
PLAT_PLIEE | +1.300 | +1.380 | 5(?) | 2
PLAT_PLIEE | +0.200 | +0.280 | 5(?) | 2
PLAT_PLIEE | +0.200 | +0.280 | 9(?) | 2
PLAT_PLIEE | +0.200 | +0.280 | 6(?) | 3
PLAT_PLIEE | +0.200 | +0.280 | 8(?) | 3
PLAT_PLIEE | +1.300 | +1.380 | 8(?) | 3
PLAT_PLIEE | +1.300 | +1.380 | 6(?) | 3

# IfcDiscreteAccessory: RENFORT TETE (2)
In: Undefined
Description: PL10*122; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +2.400; Niveau haut: +2.522; Repère de pièce: 24; Finition: GALVA; Classe: 99; Matériau: S235JR; Profil: PL10*122; Nom: RENFORT TETE
Tekla Quantités - Poids: 1.1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 29.8 m2; Surface nette: 0 m2; Hauteur: 122 mm; Largeur: 10 mm; Longueur: 124.5 mm
Pset_PlateCommon - LoadBearing: yes; Reference: 24
BaseQuantities - NetArea: 0.0323684 m2; GrossArea: 0.0151891 m2; CrossSectionArea: 0.0001 m2; NetVolume: 0.000138196 m3; GrossVolume: 0.000138196 m3
Name | Repère d'assemblage | Phase
RENFORT TETE | 8(?) | 3
RENFORT TETE | 9(?) | 2

# IfcDiscreteAccessory: SUPPORT POUTRE (4)
In: Undefined
Material: STEEL/S235JR
Tekla Commun - Finition: GALVA; Classe: 99; Matériau: S235JR; Nom: SUPPORT POUTRE
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Largeur: 10 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.0001 m2
Name | Description = Profil | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Phase | Poids (kg) | Surface par tonne (m2) | Hauteur (mm) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
SUPPORT POUTRE | PL10*125 | +1.900 | +2.050 | 20 | 9(?) | 2 | 1.4 | 29.2 | 124.5 | 150 | 0.04284 | 0.018675 | 0.00018675
SUPPORT POUTRE | PL10*122 | +2.400 | +2.522 | 18 | 9(?) | 2 | 1.1 | 29.8 | 122 | 124.5 | 0.0323684 | 0.0151891 | 0.000138196
SUPPORT POUTRE | PL10*125 | +1.900 | +2.050 | 20 | 8(?) | 3 | 1.4 | 29.2 | 124.5 | 150 | 0.04284 | 0.018675 | 0.00018675
SUPPORT POUTRE | PL10*122 | +2.400 | +2.522 | 18 | 8(?) | 3 | 1.1 | 29.8 | 122 | 124.5 | 0.0323684 | 0.0151891 | 0.000138196

# IfcDiscreteAccessory: TOLE (35)
In: Undefined
Material: STEEL/S235JR
Tekla Commun - Finition: GALVA; Classe: 99; Matériau: S235JR; Nom: TOLE
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description = Profil | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Phase | Poids (kg) | Surface par tonne (m2) | Surface nette (m2) | Hauteur (mm) | Largeur (mm) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
TOLE | PL10*113 | +2.338 | +2.368 | 17(?) | 2(?) | 4 | 0.8 | 31 | 0 | 113.2 | 10 | 138.1 | 0.0250867 | 0.0156297 | 0.0001 | 0.000103154 | 0.000103154
TOLE | PL10*113 | +2.115 | +2.145 | 17(?) | 1(?) | 2 | 0.8 | 31 | 0 | 113.2 | 10 | 138.1 | 0.0250867 | 0.0156297 | 0.0001 | 0.000103154 | 0.000103154
TOLE | PL10*113 | +2.115 | +2.145 | 17(?) | 2(?) | 4 | 0.8 | 31 | 0 | 113.2 | 10 | 138.1 | 0.0250867 | 0.0156297 | 0.0001 | 0.000103154 | 0.000103154
TOLE | PL10*113 | +2.338 | +2.368 | 17(?) | 1(?) | 2 | 0.8 | 31 | 0 | 113.2 | 10 | 138.1 | 0.0250867 | 0.0156297 | 0.0001 | 0.000103154 | 0.000103154
TOLE | PL10*113 | +2.096 | +2.126 | 17(?) | 2(?) | 4 | 0.8 | 31 | 0 | 113.2 | 10 | 138.1 | 0.0250867 | 0.0156297 | 0.0001 | 0.000103154 | 0.000103154
TOLE | PL10*113 | +1.873 | +1.903 | 17(?) | 1(?) | 2 | 0.8 | 31 | 0 | 113.2 | 10 | 138.1 | 0.0250867 | 0.0156297 | 0.0001 | 0.000103154 | 0.000103154
TOLE | PL10*113 | +1.873 | +1.903 | 17(?) | 2(?) | 4 | 0.8 | 31 | 0 | 113.2 | 10 | 138.1 | 0.0250867 | 0.0156297 | 0.0001 | 0.000103154 | 0.000103154
TOLE | PL10*113 | +2.096 | +2.126 | 17(?) | 1(?) | 2 | 0.8 | 31 | 0 | 113.2 | 10 | 138.1 | 0.0250867 | 0.0156297 | 0.0001 | 0.000103154 | 0.000103154
2 x TOLE | PL6*17 | +0.163 | +0.190 | 43 | A5 | 5 | 0 | 63.8 | 0 | 17 | 6 | 40 | 0.002044 | 0.00068 | 0.000036 | 0.00000408 | 0.00000408
TOLE | PL6*80 | +0.072 | +0.325 | 31 | A5 | 5 | 0.8 | 50.8 | 0 | 80 | 6 | 265 | 0.0353994 | 0.0212 | 0.000036 | 0.0000888 | 0.0000888
TOLE | PL6*117 | +0.040 | +0.180 | 32(?) | 4(?) | 4 | 0.8 | 46.5 | 0 | 116.7 | 6 | 140.5 | 0.032236 | 0.016388 | 0.000036 | 0.0000882215 | 0.0000894215
2 x TOLE | PL6*17 | +0.163 | +0.191 | 43 | A5 | 5 | 0 | 63.8 | 0 | 17 | 6 | 40 | 0.002044 | 0.00068 | 0.000036 | 0.00000408 | 0.00000408
TOLE | PL6*80 | +0.072 | +0.326 | 31 | A5 | 5 | 0.8 | 50.8 | 0 | 80 | 6 | 265 | 0.0353994 | 0.0212 | 0.000036 | 0.0000888 | 0.0000888
TOLE | PL6*117 | +0.040 | +0.181 | 32(?) | 5(?) | 2 | 0.8 | 46.5 | 0 | 116.7 | 6 | 140.5 | 0.0322576 | 0.0163975 | 0.000036 | 0.000088283 | 0.000089483
2 x TOLE | PL6*80 | +1.556 | +1.809 | 31 | A5 | 5 | 0.8 | 50.8 | 0 | 80 | 6 | 265 | 0.0353994 | 0.0212 | 0.000036 | 0.0000888 | 0.0000888
4 x TOLE | PL6*17 | +1.691 | +1.718 | 43 | A5 | 5 | 0 | 63.8 | 0 | 17 | 6 | 40 | 0.002044 | 0.00068 | 0.000036 | 0.00000408 | 0.00000408
TOLE | PL6*179 | +1.701 | +1.880 | 33 | A1(?) | 6 | 2.2 | 44.8 | 0.1 | 179.4 | 6 | 280 | 0.0996333 | 0.0502159 | 0.000036 | 0.000283482 | 0.000283482
2 x TOLE | PL6*110 | +1.870 | +1.940 | 34(?) | A1(?) | 6 | 0.3 | 48.4 | 0 | 110 | 6 | 70 | 0.01756 | 0.01756 | 0.00066 | 0.0000462 | 0.0000462
2 x TOLE | PL6*70 | +1.870 | +1.940 | 40(?) | A1(?) | 6 | 0.2 | 49.7 | 0 | 70 | 6 | 70 | 0.01148 | 0.01148 | 0.00042 | 0.0000294 | 0.0000294
TOLE | PL6*110 | +1.870 | +1.940 | 37 | 5(?) | 2 | 0.3 | 48.4 | 0 | 110 | 6 | 70 | 0.01756 | 0.01756 | 0.00066 | 0.0000462 | 0.0000462
TOLE | PL6*110 | +1.870 | +1.940 | 37 | 4(?) | 4 | 0.3 | 48.4 | 0 | 110 | 6 | 70 | 0.01756 | 0.01756 | 0.00066 | 0.0000462 | 0.0000462
2 x TOLE | PL6*110 | +1.895 | +1.965 | 34(?) | A2(?) | 6 | 0.3 | 48.4 | 0 | 110 | 6 | 70 | 0.01756 | 0.01756 | 0.00066 | 0.0000462 | 0.0000462
2 x TOLE | PL6*70 | +1.895 | +1.965 | 40(?) | A2(?) | 6 | 0.2 | 49.7 | 0 | 70 | 6 | 70 | 0.01148 | 0.01148 | 0.00042 | 0.0000294 | 0.0000294
TOLE | PL6*110 | +1.895 | +1.965 | 37 | 6(?) | 3 | 0.3 | 48.4 | 0 | 110 | 6 | 70 | 0.01756 | 0.01756 | 0.00066 | 0.0000462 | 0.0000462
TOLE | PL6*110 | +1.895 | +1.965 | 37 | 4(?) | 4 | 0.3 | 48.4 | 0 | 110 | 6 | 70 | 0.01756 | 0.01756 | 0.00066 | 0.0000462 | 0.0000462

# IfcDiscreteAccessory: TREILLIS (10)
In: Undefined
Description: TC-C50*50*3.2; Material: STEEL/S235JR
Tekla Commun - Repère d'assemblage: 7(?); Finition: GALVA; Phase: 1; Classe: 13; Matériau: S235JR; Profil: TC-C50*50*3.2; Nom: TREILLIS
Tekla Quantités - Volume: 0 m3; Surface par tonne: 41.6 m2; Hauteur: 50 mm; Largeur: 50 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.000588 m2
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Poids (kg) | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | NetArea (m2) = GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
TREILLIS | +2.001 | +2.450 | 1(?) | 5.3 | 0 | 0.2 | 1141.1 | 0.219098 | 0.000672283 | 0.000670987
3 x TREILLIS | +2.000 | +2.450 | 36(?) | 2.1 | 0 | 0.1 | 450 | 0.0864 | 0.000266961 | 0.0002646
TREILLIS | +2.001 | +2.450 | 39(?) | 5.3 | 0 | 0.2 | 1141.1 | 0.219099 | 0.0006697 | 0.000670992
TREILLIS | +2.001 | +2.450 | 38(?) | 5.9 | 0 | 0.4 | 1280.2 | 0.245799 | 0.00075701 | 0.000752759
TREILLIS | +2.001 | +2.450 | 38(?) | 5.9 | 0 | 0.4 | 1280.2 | 0.245777 | 0.000756942 | 0.000752692
TREILLIS | +2.000 | +2.450 | 36(?) | 2.1 | 0 | 0.1 | 450 | 0.0863998 | 0.000269567 | 0.000264599
TREILLIS | +2.000 | +2.450 | 36(?) | 2.1 | 0 | 0.1 | 450 | 0.0864 | 0.000265658 | 0.0002646
TREILLIS | +1.950 | +2.000 | 35(?) | 22.2 | 0.2 | 1 | 4820 | 0.92544 | 0.00288737 | 0.00283416

# IfcDiscreteAccessory: Unnamed (5)
In: Undefined
Description: PL10*200; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +0.030; Niveau haut: +0.040; Repère de pièce: 23(?); Finition: GALVA; Classe: 99; Matériau: S235JR; Profil: PL10*200
Tekla Quantités - Poids: 3.1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 28.5 m2; Surface nette: 0.1 m2; Hauteur: 200 mm; Largeur: 10 mm; Longueur: 200 mm
Pset_PlateCommon - LoadBearing: yes; Reference: 23(?)
BaseQuantities - NetArea: 0.0886549 m2; GrossArea: 0.088 m2; CrossSectionArea: 0.002 m2; NetVolume: 0.000395927 m3; GrossVolume: 0.0004 m3
Name | Repère d'assemblage | Phase
Unnamed | 5(?) | 2
Unnamed | 4(?) | 4
Unnamed | 9(?) | 2
Unnamed | 6(?) | 3
Unnamed | 8(?) | 3

# IfcElementAssembly (36)
In: Undefined
Name | PredefinedType | Poids Assemblage/Elément béton (kg) | Niveau Bas Assemblage/Elément béton | Niveau Haut Assemblage/Elément béton | Position maillage Assemblage/Elément béton | Repère Assemblage/Elément béton | Width (mm)
Steel Assembly | RIGID_FRAME | 0 | +1.958 | +1.989 | 3/B | A0(?) | 10
Steel Assembly | RIGID_FRAME | 70.8 | +0.030 | +2.533 | 1/A | 8(?) | 200
Steel Assembly | RIGID_FRAME | 70.8 | +0.030 | +2.533 | 3/A | 9(?) | 200
Steel Assembly | RIGID_FRAME | 69.2 | +0.030 | +2.004 | 3/B | 5(?) | 219.656
Steel Assembly | RIGID_FRAME | 69.5 | +0.030 | +2.004 | 2/B | 4(?) | 232.674
Steel Assembly | RIGID_FRAME | 68.8 | +0.030 | +2.004 | 1/B | 6(?) | 213
Steel Assembly | RIGID_FRAME | 52.9 | +1.706 | +2.562 | 2/A-B | 2(?) | 244.876
Steel Assembly | RIGID_FRAME | 84.8 | +1.900 | +2.562 | 1-3/A | 7(?) | 124.501
Steel Assembly | RIGID_FRAME | 6.5 | +2.085 | +2.354 | 2-3/A-B | A7 | 40
Steel Assembly | RIGID_FRAME | 6.5 | +2.129 | +2.403 | 2-3/A-B | A7 | 40
Steel Assembly | RIGID_FRAME | 6.5 | +1.843 | +2.112 | 2-3/A-B | A7 | 40
Steel Assembly | RIGID_FRAME | 6.5 | +1.887 | +2.162 | 2-3/A-B | A7 | 40
Steel Assembly | RIGID_FRAME | 55.6 | +1.706 | +2.508 | 3/A-B | 1(?) | 235.876
Steel Assembly | RIGID_FRAME | 11 | +1.909 | +2.016 | 2-3/B | A6 | 50
Steel Assembly | RIGID_FRAME | 11 | +1.909 | +2.016 | 1-2/B | A6 | 50
Steel Assembly | RIGID_FRAME | 52.4 | +1.706 | +2.508 | 1/A-B | 12(?) | 123.35
Steel Assembly | RIGID_FRAME | 11 | +2.151 | +2.258 | 2-3/A-B | A6 | 50
Steel Assembly | RIGID_FRAME | 11 | +2.151 | +2.258 | 1-2/A-B | A6 | 50
Steel Assembly | RIGID_FRAME | 11 | +2.393 | +2.500 | 1-2/A | A6 | 50
Steel Assembly | RIGID_FRAME | 11 | +2.393 | +2.500 | 2-3/A | A6 | 50
2 x Steel Assembly | RIGID_FRAME | 9.2 | +0.072 | +1.809 | 2-3/B | A5 | 40
Steel Assembly | RIGID_FRAME | 11.7 | +1.701 | +1.940 | 2-3/B | A1(?) | 70
Steel Assembly | RIGID_FRAME | 9.5 | +1.895 | +1.965 | 1-2/B | A2(?) | 70
Steel Assembly |  | 32.3 | +0.280 | +1.420 | 1-2/B | G2 | 10
Steel Assembly |  | 32.3 | +0.280 | +1.420 | 2-3/B | G2 | 10
Steel Assembly |  | 39 | +0.280 | +1.420 | 3/A-B | G1 | 10
Steel Assembly |  | 39 | +0.280 | +1.420 | 1/A-B | G1 | 10
Steel Assembly | RIGID_FRAME | 12.6 | +1.380 | +1.420 | 3/A-B | A4 | 40
Steel Assembly | RIGID_FRAME | 12.6 | +0.280 | +0.320 | 3/A-B | A4 | 40
Steel Assembly | RIGID_FRAME | 12 | +1.380 | +1.420 | 1-2/B | A3 | 40
Steel Assembly | RIGID_FRAME | 12 | +0.280 | +0.320 | 1-2/B | A3 | 40
Steel Assembly | RIGID_FRAME | 12 | +1.380 | +1.420 | 2-3/B | A3 | 40
Steel Assembly | RIGID_FRAME | 12 | +0.280 | +0.320 | 2-3/B | A3 | 40
Steel Assembly | RIGID_FRAME | 12.6 | +1.380 | +1.420 | 1/A-B | A4 | 40
Steel Assembly | RIGID_FRAME | 12.6 | +0.280 | +0.320 | 1/A-B | A4 | 40

# IfcMechanicalFastener: Bolt assembly (61)
In: Undefined
Tekla Boulons - Trou oblong Y: 0 mm; Trou oblong X: 0 mm; Lieu Boulonnage: Montage
Name | NominalDiameter (mm) = Diamètre rondelle (mm) = Diamètre (mm) | NominalLength (mm) = Longueur (mm) | Material = Standard | Quantité de rondelle | Type rondelle | Nom rondelle | Quantité d'écrou | Type écrou | Nom écrou | Diamètre du trou (mm) | Quantité | Nom
2 x Bolt assembly | 12 | 35 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 4 | E-8.8 | ECROU-M12-E-8.8 | 14 | 4 | M12*35
5 x Bolt assembly | 30 | 10 | 6.8 | 0 | PLA-6.8 | RONDELLE-M30-PLA-6.8 | 0 | E-6.8 | ECROU-M30-E-6.8 | 30 | 2 | M30*90
Bolt assembly | 16 | 40 | 8.8 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 4 | E-8.8 | ECROU-M16-E-8.8 | 18 | 4 | M16*40
8 x Bolt assembly | 12 | 35 | SB8.8 | 2 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-SB8.8 | ECROU-M12-E-SB8.8 | 14 | 2 | M12*35
2 x Bolt assembly | 12 | 35 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 14 | 2 | M12*35
2 x Bolt assembly | 12 | 35 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-8.8 | ECROU-M12-E-8.8 | 14 | 1 | M12*35
12 x Bolt assembly | 12 | 25 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 14 | 2 | M12*25
4 x Bolt assembly | 12 | 30 | SB8.8 | 2 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-SB8.8 | ECROU-M12-E-SB8.8 | 14 | 2 | M12*30
4 x Bolt assembly | 12 | 30 | 6.8 | 2 | PLA-6.8 | RONDELLE-M12-PLA-6.8 | 2 | E-6.8 | ECROU-M12-E-6.8 | 14 | 2 | M12*30
7 x Bolt assembly | 12 | 35 | 6.8 | 1 | PLA-6.8 | RONDELLE-M12-PLA-6.8 | 1 | E-6.8 | ECROU-M12-E-6.8 | 14 | 1 | M12*35
9 x Bolt assembly | 12 | 30 | 6.8 | 1 | PLA-6.8 | RONDELLE-M12-PLA-6.8 | 1 | E-6.8 | ECROU-M12-E-6.8 | 14 | 1 | M12*30
5 x Bolt assembly | 12 | 40 | HR8.8 | 16 | PLA-HR8.8 | RONDELLE-M12-PLA-HR8.8 | 8 | E-HR8.8 | ECROU-M12-E-HR8.8 | 14 | 8 | M12*40

# IfcMember: ROND10, POUTRE
In: Undefined
Description: ROND10; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +1.958; Niveau haut: +1.989; Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 3; Matériau: S235JR; Profil: ROND10; Nom: POUTRE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 51 m2; Surface nette: 0 m2; Hauteur: 10 mm; Largeur: 10 mm; Longueur: 30 mm
Pset_MemberCommon - LoadBearing: yes; Reference: A0(?)
BaseQuantities - Length: 30 mm; OuterSurfaceArea: 0.000942 m2; GrossSurfaceArea: 0.000942 m2; CrossSectionArea: 0.0000785 m2; NetVolume: 0.00000212132 m3; GrossVolume: 0.000002355 m3; NetWeight: 0.0166524 kg; GrossWeight: 0.0184868 kg

# IfcMember: TUBE-C-40*40*4 (2)
In: Undefined
Description: TUBE-C-40*40*4; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +0.168; Repère de pièce: 42; Repère d'assemblage: A5; Finition: GALVA; Phase: 5; Classe: 3; Matériau: S235JR; Profil: TUBE-C-40*40*4; Nom: CVT
Tekla Quantités - Poids: 7.7 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 34.8 m2; Surface nette: 0.4 m2; Hauteur: 40 mm; Largeur: 40 mm
Pset_MemberCommon - LoadBearing: yes; Reference: 42
BaseQuantities - CrossSectionArea: 0.000535 m2
Name | Niveau haut | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
CVT | +1.714 | 1838.7 | 1838.71 | 0.268452 | 0.0010591 | 0.000983712 | 8.31393 | 7.72214
CVT | +1.713 | 1837.8 | 1837.75 | 0.268312 | 0.00105854 | 0.000983197 | 8.30958 | 7.7181

# IfcPlate: PL10*1140 (4)
In: Undefined
Description: PL10*1140; Material: MISCELLANEOUS/POLYCARBONATE
Tekla Commun - Niveau bas: +0.280; Niveau haut: +1.420; Finition: GALVA; Phase: 1; Classe: 99; Matériau: POLYCARBONATE; Profil: PL10*1140; Nom: POLYCARBONATE
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 168.8 m2; Hauteur: 1140 mm; Largeur: 10 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - Width: 1140 mm; CrossSectionArea: 0.0001 m2
Name | Repère de pièce = Repère d'assemblage = Reference | Poids (kg) | Surface nette (m2) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x POLYCARBONATE | G2 | 32.3 | 5.5 | 2360 | 5.4508 | 2.6904 | 0.026904
2 x POLYCARBONATE | G1 | 39 | 6.6 | 2850 | 6.5778 | 3.249 | 0.03249
